#BRCM firmware git - tested version
SRCREV = "f6d0859f9435796f03ae93b70b5f92f4406bc56d"
