#BRCM firmware git - tested version
SRCREV = "8ce9046f5058fdd2c5271f86ccfc61bc5a248ae3"
