FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "\
	file://httpd.cfg \
	file://ctty.cfg \
"
