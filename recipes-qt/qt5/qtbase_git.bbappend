PACKAGECONFIG_append = " accessibility fontconfig linuxfb egl tslib opengl es2"
PACKAGECONFIG_remove = "examples tests"
